# Riverbank retired the original archive URL; KDE preserves the identical source tarball.
SRC_URI = "https://files.kde.org/krita/build/dependencies/PyQt5_gpl-${PV}.tar.gz"
