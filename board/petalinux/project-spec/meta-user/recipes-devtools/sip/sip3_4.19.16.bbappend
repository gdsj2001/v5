# Riverbank retired the original archive; the Yocto mirror preserves the identical source tarball.
SRC_URI = "https://downloads.yoctoproject.org/mirror/sources/sip-${PV}.tar.gz"
